## drivers/net/wireless/rockchip_wlan/rtw8852be/Kconfig
```kconfig
config RTL8852BE
	tristate "Realtek 8852B PCIE WiFi"
	help
	  Help message of RTL8852BE
```
